# Keil uVision project ledandswitchs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ledandswitchs
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s p1Active_LOW_Switches4.c LS_binary_switches.c LedSwitches_up-down_counter.c LS_display_binaary_press.c LS_Hold_switcheverysecond.c LS_EVEN_Odd_usingSwitch.c sample_LS.c
