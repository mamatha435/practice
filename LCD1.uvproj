# Keil uVision project LCD1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LCD1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s 1lcd_ch_str_int_flt.c 2_vector_institutrlcd.c 3rotate_str_lcd.c 4lcd_hh_mm_ss.c 5lcd_sw_count.c LCDsample.c lcd.c lcd.h delay.c
