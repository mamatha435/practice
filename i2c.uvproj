# Keil uVision project i2c.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: i2c
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s I2C.c I2C.h I2c_defines.h I2C_EEPROM.c I2C_EEPROM.h i2c_eeprom_test_1.c i2c_eeprom_test_2.c delay.c
